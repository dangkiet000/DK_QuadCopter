# IAR project NuvotonToArduino.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M0516LDN Nuvoton M0516LDN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __M051__
  ICCARM.CCIncludePath2: Nuvoton\ArduinoCores\nuvoton; Nuvoton\MCU_Platform\M051Series\CMSIS\Include; Nuvoton\MCU_Platform\M051Series\Device\Nuvoton\M051Series\Include; Nuvoton\MCU_Platform\M051Series\StdDriver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: NuvotonToArduino.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ArduinoCores
    Nuvoton/ArduinoCores/nuvoton/: board.cpp main.cpp Pins_arduino.cpp
  group ArduinoCores/Serial
    Nuvoton/ArduinoCores/nuvoton/: HardwareSerial.cpp Print.cpp Stream.cpp
  group ArduinoCores/Wiring
    Nuvoton/ArduinoCores/nuvoton/: WInterrupts.c wiring.c wiring_analog.c wiring_digital.c WMath.cpp WString.cpp
  group ArduinoCores/Wiring/Essential_Library
    Nuvoton/ArduinoCores/nuvoton/: dtostrf.c itoa.c
  group MCU_Platform/M051Series/Device
    Nuvoton/MCU_Platform/M051Series/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    Nuvoton/MCU_Platform/M051Series/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group MCU_Platform/M051Series/StdDriver
    Nuvoton/MCU_Platform/M051Series/StdDriver/src/: adc.c clk.c gpio.c pwm.c sys.c uart.c
